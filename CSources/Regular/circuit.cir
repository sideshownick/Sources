Random RC Network
Cx1y0X x1y0 x2y0 1.000000e+00n
Rx1y0X x1y0 x2y0 1G
Rx1y1X x1y1 x2y1 1.000000e+00k
Cx1y2X x1y2 x2y2 1.000000e+00n
Rx1y2X x1y2 x2y2 1G
Rx1y0Y x1y0 x1y1 1.000000e+00k
Cx2y0Y x2y0 x2y1 1.000000e+00n
Rx2y0Y x2y0 x2y1 1G
Cx1y1Y x1y1 x1y2 1.000000e+00n
Rx1y1Y x1y1 x1y2 1G
Rx2y1Y x2y1 x2y2 1.000000e+00k
Rx0y0X 0 x1y0 1.000000e+00k
Rx2y0X x2y0 VOUT 1.000000e+00k
Cx0y1X 0 x1y1 1.000000e+00n
Rx0y1X 0 x1y1 1G
Cx2y1X x2y1 VOUT 1.000000e+00n
Rx2y1X x2y1 VOUT 1G
Rx0y2X 0 x1y2 1.000000e+00k
Rx2y2X x2y2 VOUT 1.000000e+00k
V1 R1_N 0 AC 50
R1 VOUT R1_N 100Meg
